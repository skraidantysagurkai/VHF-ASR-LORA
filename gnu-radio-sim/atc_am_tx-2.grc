options:
  parameters:
    author: ATC Simulation
    description: ATC VHF DSB-FC AM Transmitter Simulation
    generate_options: qt_gui
    id: atc_am_tx
    output_language: python
    placement: '[0,0]'
    title: ATC VHF AM Transmitter Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: ATC audio sample rate (Hz)
    value: '8000'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: Normalised frequency offset (Doppler/oscillator drift). 0=no offset.
    gui_hint: 0,2,1,1
    label: Freq Offset (norm.)
    outputmsgname: value
    showports: 'False'
    start: '-0.01'
    step: '0.0001'
    stop: '0.01'
    value: '0.0'
  states: {}
- name: if_freq
  id: variable
  parameters:
    comment: Simulated IF carrier frequency (Hz)
    value: '10000'
  states: {}
- name: mod_index
  id: variable_qtgui_range
  parameters:
    comment: 'AM modulation index (0=no mod, 1=100%). ATC typical: 0.85-0.95'
    gui_hint: 0,0,1,1
    label: Modulation Index
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.9'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    comment: AWGN noise amplitude. 0=ideal, 0.05=~26dB SNR (good VHF), 0.2=~14dB (marginal)
    gui_hint: 0,1,1,1
    label: Channel Noise
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.005'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: IF/quadrature sample rate. Must be integer multiple of audio_rate.
    value: '240000'
  states: {}
- name: wav_file_path
  id: variable
  parameters:
    comment: Path to input WAV file (8000 Hz mono 16-bit PCM)
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/input_audio.wav"'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    comment: ZMQ socket — must match receiver
    value: '"tcp://127.0.0.1:55556"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: IF carrier at 10 kHz cosine wave.
    freq: if_freq
    offset: '0'
    phase: '0'
    samp_rate: quad_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    comment: 'ATC voice band: 300-3400 Hz (ITU telephony). Strips DC and ultrasonic.'
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3400'
    low_cutoff_freq: '300'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: 'Add 1.0 carrier offset => DSB-FC: range [1-m, 1+m]'
    const: '1.0'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Convert real AM signal to complex IQ (imag=0) for Channel Model block.
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Apply modulation index m. Scales audio to [-m, +m].
    const: mod_index
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: 'DSB-FC AM: (1 + m*audio) x carrier'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Limits CPU - prevents simulation running faster than real-time.
    samples_per_second: quad_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Reads mono WAV. repeat=True loops file for sustained simulation.
    file: wav_file_path
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: 'VHF channel: AWGN + freq offset + light multipath taps.'
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0, 0.0, 0.05, 0.0, 0.02]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    comment: 'AM spectrum: carrier at 10kHz + two voice sidebands.'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,2,3
    label: TX Spectrum
    label1: AM Signal
    name: '"ATC AM Transmitter Spectrum"'
    type: complex
    ymin: '-80'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Upsample 8000->240000 Hz (factor 30) before carrier multiply.
    decim: '1'
    interp: '30'
    taps: ''
    type: fff
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    comment: Publishes channel-impaired AM signal. Receiver subscribes to same address.
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', zeromq_pub_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
