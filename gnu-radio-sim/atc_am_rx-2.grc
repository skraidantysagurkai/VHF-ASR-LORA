options:
  parameters:
    author: ATC Simulation
    description: ATC VHF DSB-FC AM Receiver Simulation
    generate_options: qt_gui
    id: atc_am_rx
    output_language: python
    placement: '[0,0]'
    title: ATC VHF AM Receiver Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: Output audio rate Hz
    value: '8000'
  states: {}
- name: channel_bw
  id: variable
  parameters:
    comment: 'ATC channel BW: 25000 Hz (25 kHz standard)'
    value: '25000'
  states: {}
- name: if_freq
  id: variable
  parameters:
    comment: Must match TX if_freq
    value: '10000'
  states: {}
- name: output_wav_path
  id: variable
  parameters:
    comment: Path for received audio WAV output
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/output_audio.wav"'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: Must match TX quad_rate
    value: '240000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    comment: Power squelch threshold dB. -60=open (pass all). -20=tight.
    gui_hint: 0,1,1,1
    label: Squelch (dBFS)
    outputmsgname: value
    showports: 'False'
    start: '-80'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Output audio volume multiplier
    gui_hint: 0,0,1,1
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.05'
    stop: '3.0'
    value: '1.0'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    comment: Must match TX zmq_address
    value: '"tcp://127.0.0.1:55556"'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: 'Automatic gain control. rate=1e-4: slow (voice, no pumping).'
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '3400'
    audio_stop: '4500'
    chan_rate: '40000'
    comment: DSB-FC envelope detector. Decimates 40k->8k Hz. Passes 300-3400 Hz voice.
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    comment: 'Power squelch: mutes output below threshold. gate=True outputs zeros when squelched.'
    gate: 'True'
    ramp: '10'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Output volume control.
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Saves demodulated audio. Stop flowgraph via GUI (not Ctrl+C) to finalise WAV header.
    file: output_wav_path
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq
    comment: 'Tune to carrier (10kHz->0Hz) and extract 25kHz ATC channel. Decimate 6x: 240k->40k Hz.'
    decim: '6'
    samp_rate: quad_rate
    taps: firdes.low_pass(1.0, quad_rate, channel_bw/2, 2500, window.WIN_KAISER, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '40000'
    color1: '"cyan"'
    comment: Received AM signal after channelizer. Carrier at 0 Hz, sidebands +-300-3400 Hz.
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,2,2
    label: RX Spectrum
    label1: Received AM
    name: '"Received ATC AM Signal"'
    type: complex
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Demodulated audio waveform. Voice visible when signal active.
    grid: 'True'
    gui_hint: 1,2,2,1
    label1: Audio Out
    name: '"Demodulated ATC Audio"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmq_address
    comment: Receives complex IQ from TX. Start TX first.
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
