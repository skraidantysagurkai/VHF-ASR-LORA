options:
  parameters:
    author: ATC Simulation
    description: ATC VHF DSB-FC AM Receiver Simulation
    generate_options: qt_gui
    id: atc_am_rx
    output_language: python
    placement: '[0,0]'
    title: ATC VHF AM Receiver Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: channel_bw
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: output_wav_path
  id: variable
  parameters:
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/output_audio.wav"'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Squelch (dBFS)
    outputmsgname: value
    showports: 'False'
    start: '-80'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.05'
    stop: '3.0'
    value: '1.0'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:55556"'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '3400'
    audio_stop: '4500'
    chan_rate: '40000'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    gate: 'True'
    ramp: '10'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: output_wav_path
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq
    decim: '6'
    samp_rate: quad_rate
    taps: firdes.low_pass(1.0, quad_rate, channel_bw/2, 2500, window.WIN_KAISER, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '40000'
    color1: '"cyan"'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,2,2
    label: RX Spectrum
    label1: Received AM
    name: '"Received ATC AM Signal"'
    type: complex
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,2,2,1
    label1: Demodulated Audio
    name: '"Demodulated ATC Audio"'
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmq_address
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
