options:
  parameters:
    author: ATC Simulation
    description: ATC VHF DSB-FC AM Transmitter Simulation with Impulse Noise and Ricean Fading
    generate_options: qt_gui
    id: atc_am_tx
    output_language: python
    placement: '[0,0]'
    title: ATC VHF AM Transmitter Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fading_depth
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Fading Depth
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.3'
  states: {}
- name: fading_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,7,1,1
    label: Fading Offset
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.7'
  states: {}
- name: fading_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: Fading Rate (Hz)
    outputmsgname: value
    showports: 'False'
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Freq Offset (norm.)
    outputmsgname: value
    showports: 'False'
    start: '-0.01'
    step: '0.0001'
    stop: '0.01'
    value: '0.0'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: impulse_amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Impulse Amplitude
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.05'
    stop: '5.0'
    value: '0.5'
  states: {}
- name: impulse_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Impulse Rate (Hz)
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '1.0'
    stop: '500.0'
    value: '50.0'
  states: {}
- name: mod_index
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Modulation Index
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.9'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: AWGN Noise
    outputmsgname: value
    showports: 'False'
    start: '0.0'
    step: '0.005'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: wav_file_path
  id: variable
  parameters:
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/input_audio.wav"'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:55556"'
  states: {}
- name: analog_noise_source_impulse
  id: analog_noise_source_x
  parameters:
    amp: impulse_amplitude
    noise_type: analog.GR_UNIFORM
    seed: '42'
    type: complex
  states: {}
- name: analog_sig_source_fading
  id: analog_sig_source_x
  parameters:
    amp: fading_depth
    freq: fading_rate
    offset: fading_offset
    phase: '0'
    samp_rate: quad_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: if_freq
    offset: '0'
    phase: '0'
    samp_rate: quad_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3400'
    low_cutoff_freq: '300'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1.0'
    type: float
  states: {}
- name: blocks_add_impulse
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n
  id: blocks_keep_one_in_n
  parameters:
    n: max(1, int(quad_rate / max(impulse_rate, 0.001)))
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mod_index
    type: float
  states: {}
- name: blocks_multiply_fading
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: quad_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wav_file_path
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0, 0.0, 0.05, 0.0, 0.02]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,2,4
    label: TX Spectrum
    label1: AM + Fading + Impulse
    name: '"ATC AM TX Spectrum"'
    type: complex
    ymin: '-80'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '30'
    taps: ''
    type: fff
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_noise_source_impulse, '0', blocks_keep_one_in_n, '0']
- [analog_sig_source_fading, '0', blocks_multiply_fading, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_impulse, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_fading, '0']
- [blocks_keep_one_in_n, '0', blocks_add_impulse, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_fading, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', zeromq_pub_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [channels_channel_model_0, '0', blocks_add_impulse, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
