options:
  parameters:
    author: ATC Simulation
    comment: |-
      ATC VHF AM Transmitter Simulation
      Simulates DSB-FC AM modulation used in ATC communications (118-137 MHz band).
      Input: Mono WAV file (8000 Hz sample rate, 16-bit PCM)
      Output: ZMQ PUB socket → connect to atc_am_rx.grc
      Channel model simulates VHF propagation (AWGN + light multipath).
    description: ATC VHF DSB-FC AM Transmitter Simulation (no hardware required)
    id: atc_am_tx
    output_language: python
    title: ATC VHF AM Transmitter Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: ATC audio is 8 kHz, mono, 300-3400 Hz voice band
    value: '8000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    comment: Quadrature (IF) sample rate. Must be integer multiple of audio_rate. 240000 / 8000 = 30x interpolation. Gives 120 kHz bandwidth headroom (> 25 kHz ATC channel).
    value: '240000'
  states: {}
- name: if_freq
  id: variable
  parameters:
    comment: Intermediate frequency carrier (Hz). Simulates the RF carrier offset in baseband. 10 kHz places carrier well within our 120 kHz bandwidth.
    value: '10000'
  states: {}
- name: mod_index
  id: variable_qtgui_range
  parameters:
    comment: AM modulation index (0.0 to 1.0). ATC typically uses 0.85-0.95 (85-95% modulation). Values > 1.0 cause overmodulation / distortion.
    gui_hint: 0,0,1,1
    label: Modulation Index
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.9'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    comment: AWGN noise amplitude. 0.0 = no noise (ideal channel). 0.05 = ~26 dB SNR (good VHF). 0.2 = ~14 dB SNR (marginal). 0.5 = very noisy / degraded.
    gui_hint: 0,1,1,1
    label: Channel Noise
    start: '0.0'
    step: '0.005'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: Normalised frequency offset (fraction of sample rate). Simulates Doppler shift or oscillator drift. 0.0 = no offset. 0.001 = 240 Hz shift at 240 kHz SR.
    gui_hint: 0,2,1,1
    label: Freq Offset (norm.)
    start: '-0.01'
    step: '0.0001'
    stop: '0.01'
    value: '0.0'
  states: {}
- name: wav_file_path
  id: variable
  parameters:
    comment: 'Path to your input WAV file. Must be: - Mono (single channel) - 8000 Hz sample rate (or resample to match audio_rate) - 16-bit PCM Convert FLAC: ffmpeg -i input.flac -ar 8000 -ac 1 -acodec pcm_s16le input.wav'
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/input_audio.wav"'
  states: {}
- name: zmq_address
  id: variable
  parameters:
    comment: ZMQ socket address. Transmitter PUBs here; Receiver SUBs here. Use tcp://127.0.0.1:55555 for local loopback (same machine).
    value: '"tcp://127.0.0.1:55555"'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Reads mono WAV audio file. Output is float in range [-1, +1]. repeat=True loops the file continuously for sustained simulation.
    file: wav_file_path
    repeat: 'True'
    sample_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    comment: 'Restricts audio to the ATC voice telephony band: 300 Hz to 3400 Hz. This matches real ATC radio bandwidth. Kaiser window β=6.76 gives good stopband attenuation with moderate transition width.'
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3400'
    low_cutoff_freq: '300'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Apply modulation index m. Scales audio to range [-m, +m]. For 90% modulation: output range is [-0.9, +0.9].'
    const: mod_index
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: 'Add DC offset = 1.0 to create full-carrier AM. Result: 1 + m*audio → range [1-m, 1+m] = [0.1, 1.9] at m=0.9. This is DSB-FC (full carrier), as used in ATC / aviation.'
    const: '1.0'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Upsample audio from audio_rate (8000 Hz) to quad_rate (240000 Hz). Interpolation factor = 240000/8000 = 30. This prepares the modulating signal for multiplication with the IF carrier.
    decim: '1'
    interp: '30'
    taps: ''
    type: fff
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    comment: IF carrier oscillator at if_freq (10 kHz). Generates cos wave at quad_rate. This is the "RF" carrier in baseband simulation.
    amp: '1'
    freq: if_freq
    offset: '0'
    phase: '0'
    samp_rate: quad_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: 'DSB-FC AM modulation: multiply (1 + m*audio) by carrier. Output is the AM signal: [1 + m*audio(t)] × cos(2π×if_freq×t)'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Convert real AM signal to complex IQ (imaginary part = 0). The Channel Model block requires complex input. The receiver will use AM Demod (envelope detection) on the complex signal.
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: 'Simulates VHF air-ground channel impairments: - AWGN: additive white Gaussian noise (set by noise_voltage slider) - freq_offset: normalised Doppler / oscillator drift - epsilon=1.0: no sample clock offset (software sim, perfect clocking) - taps=[1, 0, 0.05, 0, 0.02]: light multipath (terrain/building reflections) Tap delays at 1/quad_rate ≈ 4.2 µs intervals VHF ATC channels are generally LOS with mild multipath near airports.'
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_seed: '0'
    noise_voltage: noise_voltage
    taps: '[1.0, 0.0, 0.05, 0.0, 0.02]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    comment: 'Spectrum of the AM signal after channel model. You should see: carrier spike at 10 kHz ± voice sidebands (300-3400 Hz each side). DSB-FC: two symmetric sidebands + strong carrier. Total BW ≈ 6.8 kHz (< 25 kHz ATC channel).'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,2,3
    label: AM Signal Spectrum (post-channel)
    label1: AM + Channel
    name: '"ATC AM Transmitter Spectrum"'
    type: complex
    ymin: '-80'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_address
    comment: Publishes the channel-impaired AM signal over ZMQ. The receiver flowgraph (atc_am_rx.grc) subscribes to this address. Run TX first, then RX. Both must use the same zmq_address.
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
