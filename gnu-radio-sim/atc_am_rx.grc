options:
  parameters:
    author: ATC Simulation
    comment: |-
      ATC VHF AM Receiver Simulation
      Demodulates DSB-FC AM signal from atc_am_tx.grc.
      Input: ZMQ SUB socket (connect to atc_am_tx.grc ZMQ PUB)
      Output: Recovered audio saved as WAV file.
      Chain: ZMQ → BPF (25 kHz ATC channel) → AGC → AM Demod → LPF → Resample → WAV Sink
    description: ATC VHF DSB-FC AM Receiver Simulation (no hardware required)
    id: atc_am_rx
    output_language: python
    title: ATC VHF AM Receiver Simulation
  states: {}

blocks:
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: zmq_address
    comment: 'Receives complex IQ samples from the transmitter flowgraph. Start atc_am_tx.grc first, then run this flowgraph. Timeout=100ms: if TX stops, RX blocks briefly then resumes polling.'
    timeout: '100'
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: if_freq
    comment: 'Frequency-translating FIR filter: channelizer + downconverter. Shifts the spectrum so that if_freq (10 kHz carrier) moves to DC (0 Hz). Simultaneously low-pass filters to channel_bw/2 = 12500 Hz half-bandwidth. Decimates by 6: 240000 / 6 = 40000 Hz output sample rate. This gives 40 kHz bandwidth > 25 kHz ATC channel. Good headroom.'
    decim: '6'
    gain: '1'
    samp_rate: quad_rate
    taps: firdes.low_pass(1.0, quad_rate, channel_bw/2, 2500, window.WIN_KAISER, 6.76)
    type: ccc
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: 'Automatic Gain Control. Normalises signal amplitude before demodulation. ATC receivers always use AGC to handle signal level variations from aircraft at different distances/elevations. rate=1e-4: slow AGC (voice-appropriate, avoids pumping on syllables). reference=1.0: target output amplitude.'
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    comment: 'Power squelch: gates audio when signal level drops below threshold. Simulates squelch found in all ATC transceivers. alpha=0.01: slow power estimation (avoids squelch chatter on voice). gate=True: outputs zero samples (not silence) when squelched.'
    gate: 'True'
    ramp: '10'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '3400'
    audio_stop: '4000'
    chan_rate: '40000'
    comment: 'AM demodulator. Performs envelope detection on the DSB-FC AM signal. Equivalent to: Complex to Mag → Add Const (-DC) → Low Pass Filter. audio_decim=5: 40000/5 = 8000 Hz output sample rate (matches audio_rate). audio_pass=3400 Hz: ATC voice band upper limit. audio_stop=4000 Hz: transition band edge. Output is float in range [-1.0, +1.0].'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume / gain control on the demodulated audio.
    const: volume
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: quad_rate
    color1: '"cyan"'
    comment: 'Spectrum of received signal before demodulation. Expect: carrier at ~0 Hz (after freq xlating), two voice sidebands ±300-3400 Hz. Noise floor visible if noise_voltage > 0 in transmitter.'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,2,2
    label: Received AM Spectrum
    label1: After Channelizer
    name: '"Received ATC AM Signal"'
    type: complex
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    comment: Time-domain waveform of demodulated ATC audio. You should see voice waveform envelope when transmission is active. Flat line when squelched or between transmissions.
    grid: 'True'
    gui_hint: 1,2,2,1
    label: Demodulated Audio
    label1: Audio Out
    name: '"Demodulated ATC Audio"'
    npoints: '8000'
    samp_rate: audio_rate
    showports: 'False'
    stem_plot: 'False'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    comment: 'Saves demodulated audio to WAV file. Output: 8000 Hz, mono, 16-bit PCM. File is written continuously while flowgraph runs. Stop the flowgraph to close/finalise the file before playing it back. Play back: ffplay /path/to/received_atc_audio.wav Or convert to FLAC: ffmpeg -i received.wav received.flac'
    file: output_wav_path
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {}

connections:
- [zeromq_sub_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
