options:
  parameters:
    author: ATC Simulation
    description: ATC VHF AM Transmission Simulation with 16kHz PCM audio
    generate_options: qt_gui
    id: atc_am_simulation
    output_language: python
    title: ATC VHF AM Simulation
  states: {}

blocks:
- name: atm_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,2,1,1
    label: Enable Atmospheric
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: atm_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Atmospheric Noise Level
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '121500'
  states: {}
- name: imd_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 3,2,1,1
    label: Enable IMD/Channel
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: imd_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: IMD / Channel Noise Level
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.05'
  states: {}
- name: imp_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 2,2,1,1
    label: Enable Impulse
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: imp_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Impulse Noise Level
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.05'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.85'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: snr_display
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,3
    label: Signal-to-Noise Ratio
    type: string
    value: '"SNR: +inf (no noise active)" if (atm_en + imp_en + imd_en == 0) else "SNR: {:.1f} dB".format(-10.0 * math.log10(max(1e-10, atm_level**2 * atm_en + imp_level**2 * imp_en + imd_level**2 * imd_en)))'
  states: {}
- name: add_imd
  id: blocks_add_xx
  parameters:
    comment: Combine IMD interferers
    num_inputs: '3'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier wave
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    comment: Envelope detection (AM demod)
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Add DC bias for AM (1 + m*x)
    const: '1.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    comment: Remove DC after demod
    const: '-1.0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Add all noise types to AM signal
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Apply modulation index
    const: mod_index
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Multiply modulated audio with carrier
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Output recovered audio
    file: /Users/ezka/Documents/output.wav
    format: FORMAT_WAV
    samp_rate: '16000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Input 16kHz PCM WAV file
    file: /Users/ezka/Documents/LDC2004S13.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: Remove sub-300Hz (below ATC voice band)
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Bandlimit audio to 300-3000Hz (ATC voice bandwidth)
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Post-demod lowpass - recover audio
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: Upsample 16kHz -> 480kHz for simulation
    phase_shift: '0'
    resamp_ratio: float(audio_rate)/float(samp_rate)
    type: float
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    comment: Downsample 480kHz -> 16kHz for output
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/float(audio_rate)
    type: float
  states: {}
- name: mult_atm
  id: blocks_multiply_const_vxx
  parameters:
    const: atm_level * atm_en
    type: float
  states: {}
- name: mult_imd
  id: blocks_multiply_const_vxx
  parameters:
    const: imd_level * imd_en
    type: float
  states: {}
- name: mult_imp
  id: blocks_multiply_const_vxx
  parameters:
    const: imp_level * imp_en
    type: float
  states: {}
- name: noise_atm
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: noise_imd_bg
  id: analog_noise_source_x
  parameters:
    amp: '0.3'
    comment: In-band Gaussian floor
    noise_type: analog.GR_GAUSSIAN
    seed: '13'
    type: float
  states: {}
- name: noise_imp
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_IMPULSE
    seed: '7'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: AM signal spectrum around carrier
    fc: carrier_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 4,0,3,3
    label1: AM Signal + Noise
    name: '"ATC AM Signal Spectrum"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 7,0,3,3
    label1: Received Audio
    name: '"Demodulated ATC Audio"'
    size: '1024'
    srate: '16000'
    type: float
  states: {}
- name: sig_imd1
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: Adjacent channel interferer 1
    freq: '122000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: sig_imd2
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: Adjacent channel interferer 2
    freq: '123000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}

connections:
- [add_imd, '0', mult_imd, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_abs_xx_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_1, '0', low_pass_filter_1, '0']
- [blocks_add_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_1, '0', mmse_resampler_xx_1, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle_0, '0']
- [mmse_resampler_xx_1, '0', audio_sink_0, '0']
- [mmse_resampler_xx_1, '0', blocks_wavfile_sink_0, '0']
- [mmse_resampler_xx_1, '0', qtgui_time_sink_x_0, '0']
- [mult_atm, '0', blocks_add_xx_0, '1']
- [mult_imd, '0', blocks_add_xx_0, '3']
- [mult_imp, '0', blocks_add_xx_0, '2']
- [noise_atm, '0', mult_atm, '0']
- [noise_imd_bg, '0', add_imd, '2']
- [noise_imp, '0', mult_imp, '0']
- [sig_imd1, '0', add_imd, '0']
- [sig_imd2, '0', add_imd, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
