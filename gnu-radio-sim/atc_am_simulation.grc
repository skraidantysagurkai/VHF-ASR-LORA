options:
  parameters:
    author: ATC Simulation
    description: ATC VHF AM Transmission Simulation with 16kHz PCM audio
    generate_options: qt_gui
    id: atc_am_simulation
    output_language: python
    title: ATC VHF AM Simulation
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '121500'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.85'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier wave
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    comment: Envelope detection (AM demod)
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Add DC bias for AM (1 + m*x)
    const: '1.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    comment: Remove DC after demod
    const: '-1.0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Add AWGN noise to AM signal
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Apply modulation index
    const: mod_index
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Multiply modulated audio with carrier
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Output recovered audio
    file: /Users/ezka/Documents/output.wav
    format: FORMAT_WAV
    samp_rate: '16000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Input 16kHz PCM WAV file
    file: /Users/ezka/Documents/LDC2004S13.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: Remove sub-300Hz (below ATC voice band)
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Bandlimit audio to 300-3000Hz (ATC voice bandwidth)
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Post-demod lowpass - recover audio
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: Upsample 16kHz -> 480kHz for simulation
    phase_shift: '0'
    resamp_ratio: float(audio_rate)/float(samp_rate)
    type: float
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    comment: Downsample 480kHz -> 16kHz for output
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/float(audio_rate)
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: AM signal spectrum around carrier
    fc: carrier_freq
    fftsize: '1024'
    grid: 'True'
    label1: AM Signal
    name: '"ATC AM Signal Spectrum"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Received Audio
    name: '"Demodulated ATC Audio"'
    size: '1024'
    srate: '16000'
    type: float
  states: {}
- name: impulse_amp
  id: variable
  parameters:
    comment: Impulse noise amplitude
    value: '0.8'
  states: {}
- name: uniform_amp
  id: variable
  parameters:
    comment: Uniform noise amplitude
    value: '0.3'
  states: {}
- name: tone_amp
  id: variable
  parameters:
    comment: Tone interferer amplitude
    value: '0.5'
  states: {}
- name: analog_noise_source_impulse
  id: analog_noise_source_x
  parameters:
    amp: impulse_amp
    comment: Impulse noise (lightning / electrical spikes)
    noise_type: analog.GR_IMPULSE
    seed: '42'
    type: float
  states: {}
- name: analog_noise_source_uniform
  id: analog_noise_source_x
  parameters:
    amp: uniform_amp
    comment: Uniform noise (wideband RF interference)
    noise_type: analog.GR_UNIFORM
    seed: '99'
    type: float
  states: {}
- name: analog_sig_source_tone
  id: analog_sig_source_x
  parameters:
    amp: tone_amp
    comment: Tone interferer (another radio nearby)
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_gate_impulse
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gate for impulse noise - toggled by random_noise_gate
    const: '0'
    type: float
  states: {}
- name: blocks_gate_uniform
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gate for uniform noise - toggled by random_noise_gate
    const: '0'
    type: float
  states: {}
- name: blocks_gate_tone
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gate for tone interferer - toggled by random_noise_gate
    const: '0'
    type: float
  states: {}
- name: blocks_add_noise_mix
  id: blocks_add_xx
  parameters:
    comment: Mix all three random noise sources
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_channel
  id: blocks_add_xx
  parameters:
    comment: Mix AM signal + AWGN + random noise mix
    num_inputs: '3'
    type: float
  states: {}
- name: random_noise_gate
  id: epy_block
  parameters:
    comment: Randomly toggles impulse/uniform/tone noise on and off
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, samp_rate=480000):
              gr.sync_block.__init__(self,
                  name='Random Noise Gate',
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.samp_rate = samp_rate
              self.counter = 0
              self.next_toggle = int(samp_rate * np.random.uniform(0.5, 3.0))
              self.gates = {'impulse': 0.0, 'uniform': 0.0, 'tone': 0.0}
              for name in self.gates:
                  self.message_port_register_out(pmt.intern(name))

          def work(self, input_items, output_items):
              n = len(input_items[0])
              output_items[0][:] = input_items[0]
              self.counter += n
              if self.counter >= self.next_toggle:
                  self.counter = 0
                  self.next_toggle = int(self.samp_rate * np.random.uniform(0.5, 3.0))
                  for name in self.gates:
                      if np.random.random() < 0.4:
                          self.gates[name] = 1.0 - self.gates[name]
                          self.message_port_pub(
                              pmt.intern(name),
                              pmt.cons(pmt.intern('val'), pmt.from_float(self.gates[name])))
              return n
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', random_noise_gate, '0']
- [random_noise_gate, '0', blocks_add_channel, '0']
- [analog_noise_source_x_0, '0', blocks_add_channel, '1']
- [blocks_add_noise_mix, '0', blocks_add_channel, '2']
- [blocks_add_channel, '0', blocks_abs_xx_0, '0']
- [blocks_add_channel, '0', qtgui_freq_sink_x_0, '0']
- [blocks_abs_xx_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_add_const_vxx_1, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', mmse_resampler_xx_1, '0']
- [mmse_resampler_xx_1, '0', audio_sink_0, '0']
- [mmse_resampler_xx_1, '0', blocks_wavfile_sink_0, '0']
- [mmse_resampler_xx_1, '0', qtgui_time_sink_x_0, '0']
- [analog_noise_source_impulse, '0', blocks_gate_impulse, '0']
- [analog_noise_source_uniform, '0', blocks_gate_uniform, '0']
- [analog_sig_source_tone, '0', blocks_gate_tone, '0']
- [blocks_gate_impulse, '0', blocks_add_noise_mix, '0']
- [blocks_gate_uniform, '0', blocks_add_noise_mix, '1']
- [blocks_gate_tone, '0', blocks_add_noise_mix, '2']
- [random_noise_gate, impulse, blocks_gate_impulse, val]
- [random_noise_gate, uniform, blocks_gate_uniform, val]
- [random_noise_gate, tone, blocks_gate_tone, val]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
