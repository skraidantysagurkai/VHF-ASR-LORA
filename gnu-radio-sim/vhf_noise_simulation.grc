options:
  parameters:
    description: VHF Radio Communication Simulation with Variable Noise – FLAC I/O at 16 kHz
    generate_options: qt_gui
    id: vhf_noise_sim
    output_language: python
    title: VHF Radio Noise Simulation (16 kHz FLAC)
  states: {}

blocks:
- name: atm_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,2,1,1
    label: Atmospheric Noise
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: imd_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,4,1,1
    label: IMD / Channel Noise
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: imp_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 0,3,1,1
    label: Impulse Noise
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: in_file
  id: variable
  parameters:
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/163249/3853-163249-0000.flac"'
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: pow(10.0, -snr_db / 20.0)
  states: {}
- name: out_file
  id: variable
  parameters:
    value: '"/Users/ezka/PycharmProjects/VHF-ASR/data/output.flac"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: SNR (dB)
    outputmsgname: value
    showports: 'False'
    start: '-20'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: add_imd
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: add_main
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: flac_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: out_file
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: flac_source
  id: blocks_wavfile_source
  parameters:
    file: in_file
    repeat: 'True'
  states: {}
- name: freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,3,5
    label1: Signal + Noise
    name: '"VHF Spectrum (16 kHz)"'
    type: float
  states: {}
- name: mult_atm
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_amp * atm_en
    type: float
  states: {}
- name: mult_imd
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_amp * imd_en
    type: float
  states: {}
- name: mult_imp
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_amp * imp_en
    type: float
  states: {}
- name: noise_atm
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: noise_imd_bg
  id: analog_noise_source_x
  parameters:
    amp: '0.3'
    noise_type: analog.GR_GAUSSIAN
    seed: '13'
    type: float
  states: {}
- name: noise_imp
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_IMPULSE
    seed: '7'
    type: float
  states: {}
- name: sig_imd1
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: sig_imd2
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '200'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,0,3,5
    label1: Signal + Noise
    name: '"VHF Time Domain"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [add_imd, '0', mult_imd, '0']
- [add_main, '0', throttle, '0']
- [flac_source, '0', add_main, '0']
- [mult_atm, '0', add_main, '1']
- [mult_imd, '0', add_main, '3']
- [mult_imp, '0', add_main, '2']
- [noise_atm, '0', mult_atm, '0']
- [noise_imd_bg, '0', add_imd, '2']
- [noise_imp, '0', mult_imp, '0']
- [sig_imd1, '0', add_imd, '0']
- [sig_imd2, '0', add_imd, '1']
- [throttle, '0', audio_out, '0']
- [throttle, '0', flac_sink, '0']
- [throttle, '0', freq_sink, '0']
- [throttle, '0', time_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
